# Keil uVision project _4_6_Marquee_GPIO_SET.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: _4_6_Marquee_GPIO_SET +hex
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\system\delay;.\system\regdef;.\system\sys;.\system\sys;.\system\typedef;.\hardware
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./user/: main.c startup_stm32f103xe.s
  group system
    ./system/typedef/: typedef.h
    ./system/sys/: sys.c sys.h
    ./system/regdef/: stm32f103zet6.h
    ./system/delay/: delay.c delay.h
  group hardware
    ./hardware/: led.c led.h
