# Keil uVision project _7_12_EXTI.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: _7_12_EXTI +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\hardware\key;..\hardware\led;..\system\delay;..\system\regdef;..\system\sys;..\system\typedef;..\hardware\exti;..\system\cortex_m3
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./: main.c startup_stm32f103xe.s
  group system
    ../system/sys/: sys.c
    ../system/delay/: delay.c
  group hardware
    ../hardware/key/: key.c
    ../hardware/led/: led.c
    ../hardware/exti/: exti.c
