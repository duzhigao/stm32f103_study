# Keil uVision project _8_12_uart_ringbuffer.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: _8_12_uart_ringbuffer +hex
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\system\regdef;..\system\sys;..\system\typedef;..\hardware\uart;..\user;..\system\cortex_m3;..\hardware\ringbuffer
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./: main.c startup_stm32f103xe.s
  group system
    ../system/sys/: sys.c
  group hardware
    ../hardware/uart/: uart.c
    ../hardware/ringbuffer/: ring_buffer.c
